options:
  parameters:
    author: shoam&iMRUM
    generate_options: qt_gui
    id: AU_adsb_rx_from_SoapyRTLSDR
    output_language: python
    title: ADS-B Reciever
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 1090e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: adsb_decoder_0
  id: adsb_decoder
  parameters:
    error_corr: '"None"'
    msg_filter: '"Extended Squitter Only"'
    print_level: '"Verbose"'
  states: {}
- name: adsb_demod_0
  id: adsb_demod
  parameters:
    fs: 2e6
  states: {}
- name: adsb_framer_0
  id: adsb_framer
  parameters:
    fs: 2e6
    threshold: '0.01'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: path/to/your/adsb/recording
    type: complex
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: Signal Strength
    yunit: db
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:9034
    timeout: '100'
  states: {}
- name: zeromq_pull_msg_source_1
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://127.0.0.1:9034
    timeout: '100'
  states: {}

connections:
- [adsb_decoder_0, decoded, zeromq_pub_msg_sink_0, in]
- [adsb_demod_0, '0', qtgui_time_sink_x_1, '0']
- [adsb_demod_0, demodulated, adsb_decoder_0, demodulated]
- [adsb_framer_0, '0', adsb_demod_0, '0']
- [blocks_complex_to_mag_squared_0, '0', adsb_framer_0, '0']
- [soapy_rtlsdr_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [soapy_rtlsdr_source_0, '0', blocks_file_sink_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [zeromq_pull_msg_source_1, out, blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
