<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>adsb_rx</value></param>
<param><key>author</key><value>Matt Hostetter</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>ADS-B Receiver</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>ant</value></param>
<param><key>value</key><value>RX2</value></param>
<param><key>gui_hint</key><value>0,3,1,1</value></param>
<param><key>label</key><value>Antenna</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>TX/RX</value></param>
<param><key>option1</key><value>RX2</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>burst_thresh</value></param>
<param><key>value</key><value>0.02</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>label</key><value>Burst Threshold</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fc</value></param>
<param><key>value</key><value>1090e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fs</value></param>
<param><key>value</key><value>4e6</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>80</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Gain (dB)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>ADSB_decoder</key>
<param><key>id</key><value>ADSB_decoder_0</value></param>
<param><key>csv_filename</key><value>""</value></param>
<param><key>db_filename</key><value>""</value></param>
<param><key>error_corr</key><value>"None"</value></param>
<param><key>log_csv</key><value>False</value></param>
<param><key>log_db</key><value>False</value></param>
<param><key>msg_filter</key><value>"Extended Squitter Only"</value></param>
<param><key>print_level</key><value>"Brief"</value></param>
</block>
<block>
<key>ADSB_demod</key>
<param><key>id</key><value>ADSB_demod_0</value></param>
<param><key>fs</key><value>fs</value></param>
</block>
<block>
<key>ADSB_framer</key>
<param><key>id</key><value>ADSB_framer_0</value></param>
<param><key>burst_thresh</key><value>burst_thresh</value></param>
<param><key>fs</key><value>fs</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>burst_thresh</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>int(fs*150e-6)</value></param>
<param><key>srate</key><value>int(fs)</value></param>
<param><key>tr_delay</key><value>1.25e-6</value></param>
<param><key>tr_level</key><value>0</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"burst"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.01</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>fc</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>fs</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>zeromq_pub_msg_sink</key>
<param><key>id</key><value>zeromq_pub_msg_sink_0</value></param>
<param><key>address</key><value>tcp://127.0.0.1:5001</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<connection><source_block_id>ADSB_decoder_0</source_block_id><sink_block_id>zeromq_pub_msg_sink_0</sink_block_id><source_key>zmq</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ADSB_demod_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ADSB_demod_0</source_block_id><sink_block_id>ADSB_decoder_0</sink_block_id><source_key>pkt</source_key><sink_key>pkt</sink_key></connection>
<connection><source_block_id>ADSB_framer_0</source_block_id><sink_block_id>ADSB_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>ADSB_framer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
